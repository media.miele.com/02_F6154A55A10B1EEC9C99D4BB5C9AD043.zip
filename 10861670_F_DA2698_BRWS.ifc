Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2022-01-05T07:52:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 05 07:52:53 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{40226B69-908E-4AA9-891B-1575A5A3013F}\ifc * Database version: 5507 * Database creation date: Wed Jan 05 07:52:52 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 05 07:52:52 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 05 07:52:52 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28269835_F_10861670_DA2698_BRWS, 10861670_F_DA2698_BRWS:28269835_F_10861670_DA2698_BRWS:207522
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Design_BRWS, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - Reference: 28269835_F_10861670_DA2698_BRWS
Pset_ManufacturerTypeInformation - Manufacturer: Miele
